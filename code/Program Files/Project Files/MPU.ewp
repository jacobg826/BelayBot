# IAR project MPU.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\Users\anton\OneDrive\Documents\BelayBot\Program Files\C Files; C:\Users\anton\OneDrive\Documents\BelayBot\Program Files\Header Files
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../C Files/: Bluetooth.c cstartup_M.c GPU.c Lab_3_Driver.c LEDs.c
    ../Header Files/: Bluetooth.h GPU.h Lab_3_Driver.h Lab_3_Header.h LEDs.h TM4CREGISTERS.h
    ./: main.c
