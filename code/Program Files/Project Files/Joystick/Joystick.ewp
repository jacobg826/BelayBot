# IAR project Joystick.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\Users\anton\OneDrive\Documents\BelayBot\Program Files\Header Files; C:\Users\anton\OneDrive\Documents\BelayBot\Program Files\C Files
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Joystick.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../C Files/: Bluetooth.c cstartup_M.c Joystick.c Lab_3_Driver.c LEDs.c
    ../../Header Files/: Bluetooth.h Joystick.h Lab_3_Driver.h Lab_3_Header.h LEDs.h TM4CREGISTERS.h
    ./: main.c
